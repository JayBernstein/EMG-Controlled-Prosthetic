# Repository JayBernstein/EMG-Controlled-Prosthetic

File README.md:

# EMG-Controlled-Prosthetic
Senior Project for Dr. Pernalete at Cal Poly Pomona, Fall 2023 - Spring 2024

## KiCad design Hardware/Amplifier/Probe_Amplifier_Rev2/INAAmplifierRev2/INAAmplifierRev2.kicad_pcb

File Hardware/README.md:

All hardware goes into here, including schematics of test circuit

The robotic hand can be found at this amazon link: https://www.amazon.com/dp/B09YR3CRSS?ref_=cm_sw_r_apan_dp_RSABRYVZYEF5RFT33YT0

Parts:
C1, C2: 0.2n; not fitted
C3, C4, C10, C11: 0.1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C5: 0.22u; CP_Radial_D4.0mm_P2.00mm; not fitted
C6, C8: 0.1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; not fitted
C7: 10u; CP_Radial_D4.0mm_P2.00mm
C9: 1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; not fitted
C12: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; not fitted
C13: 2.2u; CP_Radial_D6.3mm_P2.50mm
C14: 0.1u; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3, J4, J5, J6, J7, J8, J9, J13, J15: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J10, J11: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J12, J14: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
LED1, LED2: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R1, R4: 47.4k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R2, R3: 47.4k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal; not fitted
R5, R6: 100k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal; not fitted
R7: 56; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R8, R9, R12: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R10: 56; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; not fitted
R11: 56k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R13: 12k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R14, R15: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; not fitted
R16, R17: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TP+9V1: TPP9V; TestPoint_Pad_D4.0mm
TP-9V1: TPN9V; TestPoint_Pad_D4.0mm
TPConditionedOut1: BuffereBiasddOutput; TestPoint_Pad_D2.5mm
TPE+1: V+ Electrode; TestPoint_Pad_D4.0mm
TPE-1: V- Electrode; TestPoint_Pad_D4.0mm
TPGND1: Ground; TestPoint_Pad_D4.0mm
TPRawOut1: AmplifierOut; TestPoint_Pad_D2.5mm
TP_DCBIAS1: Buffered_Output; TestPoint_Pad_D2.5mm
U1: INA129; DIP-8_W7.62mm_LongPads
U2: LM358; DIP-8_W7.62mm_LongPads
U3: LM7805_TO220; TO-220-3_Vertical; not fitted

Connections:
+9V: C3.1, C9.1, C10.1, J7.1, J7.2, J13.1, R11.1, R16.1, TP+9V1.1, U1.7 (V+), U2.8 (V+), U3.1 (VI)
-9V: C4.1, C11.1, J8.1, J8.2, J15.2, R17.1, TP-9V1.1, U1.4 (V-), U2.4 (V-)
/ConditionedOutput: J5.1, J5.2, J6.1, J6.2, R15.1, TPConditionedOut1.1, U2.1
/DC_Bias_Buffer: J4.1, J4.2, TP_DCBIAS1.1, U2.6 (-), U2.7
/Gain1: R7.2, R10.2, U1.8 (Rg)
/Gain2: R7.1, R10.1, U1.1 (Rg)
/NegInput: C2.2, J2.1, J2.2, R3.1, R4.1, TPE-1.1
/NegInputProtected: R3.2, R4.2, R6.2, R9.2, U1.2 (-)
/PosInput: C1.1, J1.1, J1.2, R1.1, R2.1, TPE+1.1
/PosInputProtected: R1.2, R2.2, R5.1, R8.2, U1.3 (+)
GND: C1.2, C2.1, C3.2, C4.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, J3.1, J3.2, J9.1, J9.2, J10.1, J11.1, J12.1, J12.2, J12.3, J12.4, J13.2, J14.1, J14.2, J14.3, J14.4, J15.1, LED1.1 (K), LED2.2 (A), R5.2, R6.1, R8.1, R9.1, R13.1, TPGND1.1, U1.5 (Ref), U3.2 (GND)
unnamed: C7.1, C8.2, R14.2
unnamed: C12.1, U3.3 (VO)
unnamed: C5.2, C6.1, C14.1, TPRawOut1.1, U1.6
unnamed: LED1.2 (A), R16.2
unnamed: LED2.1 (K), R17.2
unnamed: C5.1, C6.2, C14.2, R11.2, R12.2, R13.2, U2.3 (+)
unnamed: R14.1, R15.2, U2.2 (-)
unnamed: C13.1, R12.1, U2.5 (+)

Notes on the sheet:
Power Rails With Indicator LEDS
TP1 and TP2 are 3.5mm Snap connectors
Output With Optional DC Gain
Inputs With Protection Resistance
72Hz High Pass Filter
LowPass Filter To Tap Off DC Offset
Grounding resistors are necessary for dc bias stability input protections resistors may not be (could hurt performance) but no conclusive evidence that it is directly harmful

Board: 2 copper layers, 99.9 x 49.9 mm, 58 parts (0 on the bottom side), 18 nets.

## KiCad design Hardware/Amplifier/INA129-Amplifier/INA129-Amplifier.kicad_pcb

Parts:
C1, C2: 0.2n; not fitted
C3, C4, C11, C12: 0.1u; C_0805_2012Metric
C5: 1u; C_0805_2012Metric; not fitted
C6: 10u; C_0805_2012Metric; not fitted
C7, C9: 10u; CP_Radial_D4.0mm_P2.00mm
C8, C10: 0.1u; C_0805_2012Metric; not fitted
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3, J4, J5, J6, J7: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J8, J9: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
R1, R4: 47.4k; R_0805_2012Metric
R2, R3: 47.4k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal; not fitted
R5, R6: 100k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal; not fitted
R7: 56; R_0805_2012Metric
R8, R9: 100k; R_0805_2012Metric
R10: 56; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal; not fitted
R11: 10k; R_0805_2012Metric
R12: 2200; R_0805_2012Metric
R13, R14: 10k; R_0805_2012Metric; not fitted
TP+9V1: TPP9V; TestPoint_Pad_D4.0mm
TP-9V1: TPN9V; TestPoint_Pad_D4.0mm
TPBiasOut1: BuffereBiasddOutput; TestPoint_Pad_D4.0mm
TPBufOut1: Buffered_Output; TestPoint_Pad_D4.0mm
TPE+1: V+ Electrode; TestPoint_Pad_D4.0mm
TPE-1: V- Electrode; TestPoint_Pad_D4.0mm
TPGND1: Ground; TestPoint_Pad_D4.0mm
TPRawOut1: AmplifierOut; TestPoint_Pad_D4.0mm
U1: INA129; DIP-8_W7.62mm_LongPads
U2: LM7805_TO220; TO-220-3_Vertical; not fitted
U3: LM358; DIP-8_W7.62mm_LongPads

Connections:
+9V: C3.1, C5.1, C11.1, J3.1, J3.2, R11.1, TP+9V1.1, U1.7 (V+), U2.1 (VI), U3.8 (V+)
-9V: C4.1, C12.1, J4.1, J4.2, TP-9V1.1, U1.4 (V-), U3.4 (V-)
/BufferedOutput: C7.2, C8.1, TPBufOut1.1, U3.1, U3.2 (-)
/ConditionedOutput: J6.1, J6.2, J7.1, J7.2, R13.1, TPBiasOut1.1, U3.7
/Gain1: R7.2, R10.2, U1.8 (Rg)
/Gain2: R7.1, R10.1, U1.1 (Rg)
/NegInput: C2.2, J2.1, J2.2, R3.1, R4.1, TPE-1.1
/NegInputProtected: R3.2, R4.2, R6.2, R9.2, U1.2 (-)
/PosInput: C1.1, J1.1, J1.2, R1.1, R2.1, TPE+1.1
/PosInputProtected: R1.2, R2.2, R5.1, R8.2, U1.3 (+)
/UnBufferedOutput: TPRawOut1.1, U1.6, U3.3 (+)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C9.2, C10.1, C11.2, C12.2, J5.1, J5.2, J8.1, J9.1, R5.2, R6.1, R8.1, R9.1, R12.2, TPGND1.1, U1.5 (Ref), U2.2 (GND)
unnamed: C6.1, U2.3 (VO)
unnamed: C9.1, C10.2, R14.2
unnamed: C7.1, C8.2, R11.2, R12.1, U3.5 (+)
unnamed: R13.2, R14.1, U3.6 (-)

Notes on the sheet:
TP1 and TP2 are 3.5mm Snap connectors
Ground Tied Ref might need to be changed Could affect system stability
Grounding resistors are necessary for dc bias stability input protections resistors may not be (could hurt performance) but no conclusive evidence that it is directly harmful

Board: 2 copper layers, 99.9 x 49.9 mm, 45 parts (0 on the bottom side), 15 nets.

## Commit log

2024-01-26 Initializing directories
2024-01-26 Initializing repositories with README
2024-01-27 Added the amplifier circuit with a printout in KiCAD
2024-01-27 Adding previous arduino software used in testing
2024-01-27 Added bare cornell simulation for LTSPICE
2024-01-27 adding Juan's signal processing Jupyter Notebook
2024-02-02 Added Simulation of Half wave rectifier and a model equvialent to skin impedance
2024-02-26 Created INA Amplifier Rev1, created outputs for shipped model
2024-02-26 Simulation of filters
2024-02-28 Moved Old Filter Implementation, Saved First draft of new filter implementation
2024-02-28 Improved the Sampling System for filter implementation
2024-02-29 Created Rev2 Of the amplifier PCB
2024-02-29 fixed the INA AMplifer DC Bias Buffer
2024-03-02 Added a simulation of the low pass and high pass filters implemented on Rev 2 of the probe board
2024-03-05 added basic revision of data acquisition, not verified and requires more work
2024-03-05 Changed power connectors, added film caps, general corrections for rev 2
2024-03-07 Added indicators for LEDs and created outputs to ship for Rev2
2024-03-13 Add files via upload
    Includes first order chebyshev filter with lower corner cutoff at 1500Hz (Sampled at 44kHz). This code centers the waveform, rectifies it and uses exponential gain to amplify signal values. This is t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
2024-03-18 Added Measurements Folder and Preliminary Gain Measurements for Comparison
2024-03-18 Added new measurement of gain, recorded death of rev2 board 4
2024-03-20 Added Preliminary Code to use Pi pico with HC-05 as bluetooth master communicator
2024-03-27 Added ability for micropython to grab byte from UART and translate to PWM
2024-03-27 Added Frequency Response of new INA828 boards 6 and 7
2024-03-31 Added Previous work to implement new probe boards, and two probe analysis
2024-04-01 Added new ADC library test and averaging reimplementation in twoprobecode_new
2024-04-01 Uploading Autothresholding as-is, can be modified to work with fist but multiple fingers not very functional.
2024-04-08 Added new Directory to hold acquired data for processing
2024-04-08 Added some examples of the outputs from signal processing for poster and summary
2024-04-08 Updated Autothreshold to remove dcoffset bug in signal processing
2024-04-10 added presentation template and initialized new location for presentation material
2024-04-11 Just added a title, borders to presentation material
2024-04-11 Added in the working hand open close code
2024-04-11 Updated Libraries for Sample time and nonblocking servo operation, untested
2024-04-11 Adding images and charts to presentation, generating presentation schematics
2024-04-13 Adding new blocks and some abstract text to the Presentation
2024-04-15 Added a preliminary block diagram to powerpoint
2024-04-15 Added Deadzones, increased available ram by removing array, fixed pin assignments
2024-04-15 Changed simulation slightly for presentation material, made distance calculation affect whole hand
2024-04-15 Total Control
    This is new code for everything integrated including debug mode, two probes, new libraries. Works to control total hand and middle and ring.
2024-04-18 Started to implement autothresholding. Created first draft of presentation material, with probe gain measurements
2024-04-20 Updated Presentation material in order to make it standard size for printing. Significant changes to layout but not much new material
2024-04-21 Attempting to get autothreshsolding working. Currently need to reimplement gain on filter acquisition, visuallize level outputs. Algorithm for getting thresholds seems solid
2024-04-21 New cleaned up horizontal poster and pdf export for draft 2
2024-04-22 Added picture of setup, exported new pdf with smaller image sizes. Charts require rework, Decrease font of titles and decrease size
2024-04-22 Shipped major changes to AdvancedBP..., kept single filter and autothresholding in Basic... untested still
2024-04-22 added a simple graphic for distance thresholding, and davids draft of software hardware. need to fix color scheme, add amplitude thresholding
2024-04-23 Added David's previous finger amplitude data to illustrate thresholding. New Layout with space for Juan's control diagram
2024-04-24 Edited to final draft of the poster board
2024-04-24 A few final tweaks to presentation material
2024-04-24 Saved and exported final version of poster board.
2024-04-26 Final corrections that didn't make it onto physical board print
2024-04-30 Added a modified picture, fixed the error in the title of the poster board
2024-04-30 Moved items to folders for clarity
2024-05-14 Updated probe measurements, created new outputs for the corrected EMG poster
